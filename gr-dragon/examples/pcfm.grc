options:
  parameters:
    author: shane
    generate_options: qt_gui
    id: pcfm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: code_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: oversampling
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: pcfm.dat
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: p4.dat
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: code_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: code_len*oversampling
    type: float
  states: {}
- name: dragon_oversample_vector_0
  id: dragon_oversample_vector
  parameters:
    over: oversampling
    vlen: code_len
  states: {}
- name: dragon_phase_code_generator_0
  id: dragon_phase_code_generator
  parameters:
    code_len: code_len
    code_type: '"P4"'
    repeat: 'True'
    repetitions: '1'
    tags: '[]'
  states: {}
- name: pcfm_modulator_0
  id: pcfm_modulator
  parameters:
    code_len: code_len
    oversampling: oversampling
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: PCFM
    label2: P4
    name: Phase Function Comparison
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
    yunit: radians
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', pcfm_modulator_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0, '1']
- [dragon_oversample_vector_0, '0', blocks_vector_to_stream_0_0, '0']
- [dragon_phase_code_generator_0, '0', blocks_vector_to_stream_0, '0']
- [dragon_phase_code_generator_0, '0', dragon_oversample_vector_0, '0']
- [pcfm_modulator_0, '0', blocks_file_sink_0, '0']
- [pcfm_modulator_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
