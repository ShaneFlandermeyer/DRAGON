options:
  parameters:
    author: Shane Flandermeyer
    comment: |-
      Modulates a phase code with the PCFM framework, and
      plots a comparison of the phase functions along with the resulting 
      complex baseband waveform.
    generate_options: qt_gui
    id: pcfm
    output_language: python
    title: PCFM
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: code_len/pulse_width
  states: {}
- name: chip_width
  id: variable
  parameters:
    value: samp_interval*oversampling
  states: {}
- name: code_len
  id: variable
  parameters:
    value: '200'
  states: {}
- name: oversampling
  id: variable
  parameters:
    value: '16'
  states: {}
- name: pulse_width
  id: variable
  parameters:
    value: chip_width*code_len
  states: {}
- name: samp_interval
  id: variable
  parameters:
    value: 1/samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: code_len*oversampling
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: code_len*oversampling
    type: float
  states: {}
- name: dragon_complex_exponential_0
  id: dragon_complex_exponential
  parameters: {}
  states: {}
- name: dragon_oversample_vector_0
  id: dragon_oversample_vector
  parameters:
    over: oversampling
    vlen: code_len
  states: {state: disabled}
- name: dragon_oversample_vector_1
  id: dragon_oversample_vector
  parameters:
    over: oversampling
    vlen: code_len
  states: {}
- name: dragon_pcfm_mod_0
  id: dragon_pcfm_mod
  parameters:
    code_len: code_len
    oversampling: int(oversampling)
    samp_rate: int(samp_rate)
    type: dragon.cpm.LREC
  states: {}
- name: dragon_phase_code_generator_0
  id: dragon_phase_code_generator
  parameters:
    code_len: code_len
    repeat: 'True'
    tags: '[]'
    type: dragon.phase_code.P4
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Complex-Baseband Waveform
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: PCFM
    label2: P4
    name: Phase Function Comparison
    nconnections: '2'
    size: code_len*oversampling
    srate: samp_rate
    type: float
    ylabel: Phase
    yunit: radians
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_vector_to_stream_0_0, '0', qtgui_time_sink_x_0, '1']
- [dragon_complex_exponential_0, '0', qtgui_sink_x_0, '0']
- [dragon_oversample_vector_0, '0', blocks_vector_to_stream_0, '0']
- [dragon_oversample_vector_1, '0', blocks_vector_to_stream_0_0, '0']
- [dragon_pcfm_mod_0, '0', dragon_complex_exponential_0, '0']
- [dragon_pcfm_mod_0, '0', qtgui_time_sink_x_0, '0']
- [dragon_phase_code_generator_0, '0', dragon_oversample_vector_0, '0']
- [dragon_phase_code_generator_0, '0', dragon_oversample_vector_1, '0']
- [dragon_phase_code_generator_0, '0', dragon_pcfm_mod_0, '0']

metadata:
  file_format: 1
