options:
  parameters:
    generate_options: qt_gui
    id: p4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: length
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1024'
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: dragon_pdu_phase_code_generator_0
  id: dragon_pdu_phase_code_generator
  parameters:
    code_len: length
    repeat: 'True'
    type: dragon.phase_code.P4
  states: {}
- name: pdu_utils_pdu_to_bursts_X_0
  id: pdu_utils_pdu_to_bursts_X
  parameters:
    depth: '2048'
    early_behavior: pdu_utils.EARLY_BURST_BEHAVIOR__APPEND
    type: f
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: code_len
    type: int
    value: length
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle_1, '0', qtgui_time_sink_x_0, '0']
- [dragon_pdu_phase_code_generator_0, out, pdu_utils_pdu_to_bursts_X_0, bursts]
- [pdu_utils_pdu_to_bursts_X_0, '0', blocks_throttle_1, '0']
- [qtgui_edit_box_msg_0, msg, dragon_pdu_phase_code_generator_0, ctrl]

metadata:
  file_format: 1
