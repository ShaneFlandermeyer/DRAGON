options:
  parameters:
    generate_options: qt_gui
    id: p4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: code_len
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '1024'
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: code_len
    type: float
  states: {}
- name: dragon_phase_code_generator_0
  id: dragon_phase_code_generator
  parameters:
    code_len: code_len
    code_type: '"P4"'
    repeat: 'True'
    repetitions: '1'
    tags: '[]'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle_0, '0']
- [dragon_phase_code_generator_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
