options:
  parameters:
    generate_options: qt_gui
    id: fft_convolution
    output_language: python
    thread_safe_setters: '1'
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 10e6
  states: {state: disabled}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 100e6
    value: 5e6
  states: {}
- name: duty_factor
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: sig_len+filt_len-1+225
  states: {}
- name: filt_len
  id: variable
  parameters:
    value: int(samp_rate*sweep_time)
  states: {}
- name: prf
  id: variable
  parameters:
    value: 1/pri
  states: {}
- name: pri
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sig_len
  id: variable
  parameters:
    value: int(samp_rate*sweep_time)
  states: {}
- name: sweep_time
  id: variable
  parameters:
    value: duty_factor*pri
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_len
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: sig_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: sig_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: fft_len
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: dragon_cl_db_0
  id: dragon_cl_db
  parameters:
    dev_id: '1'
    devices: '1'
    mode: dragon.VOLTAGE
    ocl_platform_type: '1'
    platform_id: '1'
    set_debug: '0'
  states: {}
- name: dragon_convolve_fft_hier_0
  id: dragon_convolve_fft_hier
  parameters:
    fft_size: fft_len
    nthreads: '1'
    window: window.rectangular(fft_len)
  states: {}
- name: dragon_pad_vector_0
  id: dragon_pad_vector
  parameters:
    comment: |-
      Pad the vectors to 
      the correct length
    new_len: fft_len
    old_len: sig_len
  states: {}
- name: dragon_pad_vector_0_0
  id: dragon_pad_vector
  parameters:
    new_len: fft_len
    old_len: sig_len
  states: {}
- name: dragon_pdu_lfm_0
  id: dragon_pdu_lfm
  parameters:
    bandwidth: bandwidth
    mode: dragon.TX_MODE__LOOPBACK
    prf: prf
    repeat: 'True'
    samp_rate: samp_rate
    sweep_time: sweep_time
  states: {}
- name: dragon_pdu_to_stream_X_0
  id: dragon_pdu_to_stream_X
  parameters:
    add_tags: 'True'
    early_burst_behavior: dragon.EARLY_BURST_BEHAVIOR__APPEND
    max_queue_size: '64'
    type: c
    verbose: 'True'
  states: {}
- name: dragon_pdu_to_stream_X_0_0
  id: dragon_pdu_to_stream_X
  parameters:
    add_tags: 'True'
    early_burst_behavior: dragon.EARLY_BURST_BEHAVIOR__APPEND
    max_queue_size: '64'
    type: c
    verbose: 'True'
  states: {}
- name: pdu_utils_pdu_add_noise_0
  id: pdu_utils_pdu_add_noise
  parameters:
    dist: pdu_utils.UNIFORM
    level: '0.01'
    offset: '0.0'
    scale: '1.0'
    seed: '123456789'
  states: {state: bypassed}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: fft_len
    x_axis_label: delay
    x_start: '0'
    x_step: '1.0'
    y_axis_label: magnitude
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', dragon_pad_vector_0, '0']
- [blocks_stream_to_vector_0_0, '0', dragon_pad_vector_0_0, '0']
- [blocks_stream_to_vector_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_throttle_0_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_vector_to_stream_0, '0', dragon_cl_db_0, '0']
- [dragon_cl_db_0, '0', blocks_stream_to_vector_1, '0']
- [dragon_convolve_fft_hier_0, '0', blocks_throttle_0_0, '0']
- [dragon_pad_vector_0, '0', dragon_convolve_fft_hier_0, '1']
- [dragon_pad_vector_0_0, '0', dragon_convolve_fft_hier_0, '0']
- [dragon_pdu_lfm_0, filter, dragon_pdu_to_stream_X_0_0, in]
- [dragon_pdu_lfm_0, out, pdu_utils_pdu_add_noise_0, pdu_in]
- [dragon_pdu_to_stream_X_0, '0', blocks_stream_to_vector_0, '0']
- [dragon_pdu_to_stream_X_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [pdu_utils_pdu_add_noise_0, pdu_out, dragon_pdu_to_stream_X_0, in]

metadata:
  file_format: 1
