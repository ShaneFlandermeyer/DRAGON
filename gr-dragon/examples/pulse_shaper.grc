options:
  parameters:
    generate_options: qt_gui
    id: pulse_shaper
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: code_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: oversampling
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: oversampling*code_len
    type: float
  states: {}
- name: dragon_difference_xx_0
  id: dragon_difference_xx
  parameters:
    type: float
    vlen: code_len
  states: {}
- name: dragon_oversample_vector_0
  id: dragon_oversample_vector
  parameters:
    over: oversampling
    vlen: code_len
  states: {}
- name: dragon_phase_code_generator_0
  id: dragon_phase_code_generator
  parameters:
    code_len: code_len
    code_type: '"P4"'
    repeat: 'True'
    repetitions: '1'
    tags: '[]'
  states: {}
- name: dragon_shaping_filt_0
  id: dragon_shaping_filt
  parameters:
    filt_len: oversampling
    filt_type: '"Rectangular"'
    vlen: oversampling*code_len
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: PCFM
    name: Phase Function Comparison
    size: code_len*oversampling
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Phase
    yunit: radians
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [dragon_difference_xx_0, '0', dragon_oversample_vector_0, '0']
- [dragon_oversample_vector_0, '0', dragon_shaping_filt_0, '0']
- [dragon_phase_code_generator_0, '0', dragon_difference_xx_0, '0']
- [dragon_shaping_filt_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
