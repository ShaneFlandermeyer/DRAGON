options:
  parameters:
    generate_options: no_gui
    id: test_mts
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sig_freq_tx
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: sig_prf
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: tgt_rcs
  id: variable
  parameters:
    value: '[1,100]'
  states: {}
- name: tgt_rng
  id: variable
  parameters:
    value: '[1000,25000]'
  states: {}
- name: tgt_vel
  id: variable
  parameters:
    value: '[100,-100]'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1585'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: EOB
    false_value: 'False'
    true_key: SOB
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/shane/chirpRx.dat
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/shane/chirpTx.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dragon_moving_target_sim_py_0
  id: dragon_moving_target_sim_py
  parameters:
    end_tag_key: EOB
    pad_pulses: 'True'
    samp_rate: samp_rate
    sig_comp_pulsewidth: '100e-6'
    sig_freq_tx: sig_freq_tx
    sig_prf: sig_prf
    start_tag_key: SOB
    tgt_rcs: tgt_rcs
    tgt_rng: tgt_rng
    tgt_vel: tgt_vel
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_short_0, '0']
- [blocks_add_xx_0, '0', dragon_moving_target_sim_py_0, '0']
- [blocks_burst_tagger_0, '0', blocks_add_xx_0, '0']
- [blocks_burst_tagger_0, '0', dragon_moving_target_sim_py_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_burst_tagger_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_throttle_0, '0', blocks_complex_to_mag_0, '0']
- [dragon_moving_target_sim_py_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
