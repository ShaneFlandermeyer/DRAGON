options:
  parameters:
    generate_options: qt_gui
    id: mts
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: data1
  id: variable
  parameters:
    value: pmt.init_c32vector(1000,range(1000, 0, -1))
  states: {state: disabled}
- name: duty_cycle
  id: variable
  parameters:
    value: sweep_time*prf
  states: {}
- name: lfm_bandwidth
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: prf
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sweep_time
  id: variable
  parameters:
    value: '40e-6'
  states: {}
- name: tgt_rcs
  id: variable
  parameters:
    value: '[100]'
  states: {}
- name: tgt_rng
  id: variable
  parameters:
    value: '[5000]'
  states: {}
- name: tgt_vel
  id: variable
  parameters:
    value: '[0]'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.01'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/shane/chirpRx.dat
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dragon_lfm_source_0
  id: dragon_lfm_source
  parameters:
    add_tags: 'True'
    append_zeros: 'True'
    bandwidth: lfm_bandwidth
    chirp_type: Upchirp
    prf: prf
    repeat: 'True'
    samp_rate: samp_rate
    sweep_time: sweep_time
    tags: '["SOB","EOB"]'
  states: {}
- name: dragon_moving_target_sim_0
  id: dragon_moving_target_sim
  parameters:
    prf: prf
    samp_rate: samp_rate
    tgt_rcs: tgt_rcs
    tgt_rng: tgt_rng
    tgt_vel: tgt_vel
    tx_freq: tx_freq
  states: {}
- name: pdu_utils_pdu_to_bursts_X_0
  id: pdu_utils_pdu_to_bursts_X
  parameters:
    depth: '2048'
    early_behavior: pdu_utils.EARLY_BURST_BEHAVIOR__APPEND
    type: c
  states: {}
- name: pdu_utils_tags_to_pdu_X_0
  id: pdu_utils_tags_to_pdu_X
  parameters:
    boost_time: 'False'
    cfg_port: 'False'
    end_tag: EOB
    eob_alignment: '1'
    eob_offset: '0'
    max_pdu_size: '1024'
    prepend: '[]'
    pub_det: 'False'
    rate: samp_rate
    start_tag: SOB
    start_time: '0.0'
    tail_size: '0'
    type: c
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plottime: 'False'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', pdu_utils_tags_to_pdu_X_0, '0']
- [dragon_lfm_source_0, '0', blocks_throttle_0, '0']
- [dragon_moving_target_sim_0, out, pdu_utils_pdu_to_bursts_X_0, bursts]
- [pdu_utils_pdu_to_bursts_X_0, '0', blocks_add_xx_0, '0']
- [pdu_utils_tags_to_pdu_X_0, pdu_out, dragon_moving_target_sim_0, in]

metadata:
  file_format: 1
