options:
  parameters:
    author: shane
    generate_options: qt_gui
    id: lfm_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: duty_factor
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: filt_len
  id: variable
  parameters:
    value: int(samp_rate*sweep_time)
  states: {}
- name: out_len
  id: variable
  parameters:
    value: sig_len+filt_len-1
  states: {}
- name: prf
  id: variable
  parameters:
    value: 1/pri
  states: {}
- name: pri
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sig_len
  id: variable
  parameters:
    value: filt_len
  states: {}
- name: sweep_time
  id: variable
  parameters:
    value: duty_factor*pri
  states: {}
- name: dragon_pdu_lfm_0
  id: dragon_pdu_lfm
  parameters:
    bandwidth: bandwidth
    mode: dragon.TX_MODE__SIMULATION
    prf: prf
    repeat: 'True'
    samp_rate: samp_rate
    sweep_time: sweep_time
  states: {}
- name: dragon_pdu_to_stream_X_0
  id: dragon_pdu_to_stream_X
  parameters:
    add_tags: 'True'
    early_burst_behavior: dragon.EARLY_BURST_BEHAVIOR__APPEND
    max_queue_size: '64'
    type: c
    verbose: 'True'
  states: {}
- name: pdu_utils_pdu_add_noise_0
  id: pdu_utils_pdu_add_noise
  parameters:
    dist: pdu_utils.UNIFORM
    level: '0.01'
    offset: '0.0'
    scale: '1.0'
    seed: '123456789'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: bandwidth
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [dragon_pdu_lfm_0, out, pdu_utils_pdu_add_noise_0, pdu_in]
- [dragon_pdu_to_stream_X_0, '0', qtgui_sink_x_0, '0']
- [pdu_utils_pdu_add_noise_0, pdu_out, dragon_pdu_to_stream_X_0, in]
- [qtgui_edit_box_msg_0, msg, dragon_pdu_lfm_0, ctrl]

metadata:
  file_format: 1
