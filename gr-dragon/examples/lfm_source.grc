options:
  parameters:
    author: shane
    generate_options: qt_gui
    id: lfm_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    label: Bandwidth
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: samp_rate
    value: 5e6
  states: {}
- name: duty_factor
  id: variable_qtgui_range
  parameters:
    label: Duty Factor
    orient: Qt.Horizontal
    start: '0'
    step: '.01'
    stop: '1'
    value: '.1'
  states: {}
- name: prf
  id: variable_qtgui_range
  parameters:
    label: PRF
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '10000'
    value: '5000'
  states: {}
- name: pri
  id: variable
  parameters:
    value: 1/prf
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Sample Rate
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: 100e6
    value: 20e6
  states: {}
- name: sweep_time
  id: variable
  parameters:
    value: duty_factor/prf
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: int(samp_rate*pri)
    type: complex
  states: {}
- name: lfm_source_0
  id: lfm_source
  parameters:
    bandwidth: bandwidth
    prf: prf
    samp_rate: samp_rate
    sweep_time: sweep_time
    tags: '[]'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: int(pri*samp_rate)
    type: complex
    wintype: firdes.WIN_RECTANGULAR
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_throttle_0, '0']
- [lfm_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
