options:
  parameters:
    author: shane
    generate_options: qt_gui
    id: lfm_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: duty_factor
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: prf
  id: variable
  parameters:
    value: 1/pri
  states: {}
- name: pri
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sweep_time
  id: variable
  parameters:
    value: duty_factor*pri
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 0, 0, -1, -1, -1, -1, 1, 1, -1, -1, -1, 1, -1, 1, 1, 1, 1, 1, -1, -1, -1, -1, -1, 1, -1, -1, 1, -1, 0, 1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, 1, 1, 1, -1, 1, -1, -1, -1, 1, -1, 1, -1, -1, -1, -1, 0, 0, 0, 0, 0] '
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/shane/chirpRx.dat
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dragon_lfm_pdu_0
  id: dragon_lfm_pdu
  parameters:
    bandwidth: bandwidth
    mode: dragon.LFM_GENERATOR_MODE__SIMULATION
    prf: prf
    samp_rate: samp_rate
    sweep_time: sweep_time
  states: {}
- name: dragon_moving_target_sim_0
  id: dragon_moving_target_sim
  parameters:
    mode: dragon.LFM_GENERATOR_MODE__SIMULATION
    prf: prf
    samp_rate: samp_rate
    tgt_rcs: '[10,100,100,100000]'
    tgt_rng: '[1000,2000,10000,26000]'
    tgt_vel: '[-100,0,100,100]'
    tx_freq: 2.4e9
  states: {state: bypassed}
- name: dragon_pdu_to_stream_x_0
  id: dragon_pdu_to_stream_x
  parameters:
    early_burst_behavior: dragon.EARLY_BURST_BEHAVIOR__APPEND
    max_queue_size: '2048'
    type: c
    verbose: 'False'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: bandwidth
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [dragon_lfm_pdu_0, out, dragon_moving_target_sim_0, in]
- [dragon_moving_target_sim_0, out, dragon_pdu_to_stream_x_0, bursts]
- [dragon_pdu_to_stream_x_0, '0', blocks_throttle_0, '0']
- [qtgui_edit_box_msg_0, msg, dragon_lfm_pdu_0, ctrl]

metadata:
  file_format: 1
