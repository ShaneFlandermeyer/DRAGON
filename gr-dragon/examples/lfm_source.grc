options:
  parameters:
    author: shane
    generate_options: qt_gui
    id: lfm_source
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: code_len
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: duty_factor
  id: variable
  parameters:
    value: '1'
  states: {}
- name: prf
  id: variable
  parameters:
    value: 1/pri
  states: {}
- name: pri
  id: variable
  parameters:
    value: '200e-6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: sweep_time
  id: variable
  parameters:
    value: duty_factor*pri
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dragon_lfm_source_0
  id: dragon_lfm_source
  parameters:
    add_tags: 'True'
    append_zeros: 'True'
    bandwidth: bandwidth
    chirp_type: Upchirp
    prf: prf
    repeat: 'True'
    samp_rate: samp_rate
    sweep_time: sweep_time
    tags: '["SOB","EOB"]'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '256'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [dragon_lfm_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
