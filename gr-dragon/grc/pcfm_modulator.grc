options:
  parameters:
    author: Shane Flandermeyer
    category: '[dragon]'
    comment: |-
      Modulate the input phase code with the PCFM framework
      (FIXME: Always assumes rectangular shaping filter)
    description: Modulate the input phase code with the PCFM framework
    generate_options: hb
    id: pcfm_modulator
    output_language: python
    thread_safe_setters: '1'
    title: PCFM Modulator
  states: {}

blocks:
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: code_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: code_len*oversampling
    type: float
  states: {}
- name: code_len
  id: parameter
  parameters:
    label: Code Length
    type: intx
    value: '1'
  states: {}
- name: dragon_difference_xx_0
  id: dragon_difference_xx
  parameters:
    type: float
    vlen: code_len
  states: {}
- name: dragon_dti_0
  id: dragon_dti
  parameters:
    decim: '1'
    vlen: code_len*oversampling
  states: {}
- name: dragon_oversample_vector_0
  id: dragon_oversample_vector
  parameters:
    over: oversampling
    vlen: code_len
  states: {}
- name: dragon_pulse_shaper_0
  id: dragon_pulse_shaper
  parameters:
    beta: '0.3'
    filt_len: '1'
    h: '0.5'
    oversampling: oversampling
    type: dragon.cpm.LREC
    vlen: oversampling*code_len
  states: {state: disabled}
- name: dragon_shaping_filt_0
  id: dragon_shaping_filt
  parameters:
    filt_len: oversampling
    filt_type: '"Rectangular"'
    vlen: code_len*oversampling
  states: {}
- name: oversampling
  id: parameter
  parameters:
    label: Oversampling Rate
    type: intx
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: Code
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: '1'
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', dragon_difference_xx_0, '0']
- [blocks_vector_to_stream_0, '0', pad_sink_0, '0']
- [dragon_difference_xx_0, '0', dragon_oversample_vector_0, '0']
- [dragon_dti_0, '0', blocks_vector_to_stream_0, '0']
- [dragon_oversample_vector_0, '0', dragon_pulse_shaper_0, '0']
- [dragon_oversample_vector_0, '0', dragon_shaping_filt_0, '0']
- [dragon_pulse_shaper_0, '0', dragon_dti_0, '0']
- [dragon_shaping_filt_0, '0', dragon_dti_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
